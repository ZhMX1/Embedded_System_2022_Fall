# IAR project Project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\Libraries\CMSIS\Include; ..\..\User\bsp; ..\..\User\bsp\inc; ..\..\User\app\inc; ..\..\User\fonts; ..\..\User\images; ..\..\User\uIP\uip; ..\..\User\uIP\http; ..\..\User\uIP\dm9000; ..\..\User\FatFS\src; ..\..\User\usb_mass; ..\..\User\CH376\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: stm32-f3.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CpuRAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\User\bsp_stm32f4xx; ..\..\User\bsp_stm32f4xx\inc; ..\..\User
  ILINK.IlinkOutputFile: stm32-f4.out
  ILINK.IlinkIcfFile: stm32f4xx_ram.icf
  group App
    ../../User/app/src/: ad7705_test.c audio_rec.c bmp_file.c can_network.c fm_radio.c form_ad9833.c form_can.c form_dac8501.c form_dac8562.c form_dso.c form_rs485.c form_step_moto.c gprs_test.c hard_test.c http_server.c main.c main_menu.c mems_test.c mp3_player.c num_pad.c oled_test.c param.c ra8875_flash.c reserve.c touch_test.c usbd_msc_test.c WaveMaker.c wifi_test.c
  group BSP
    ../../User/bsp/: bsp.c bsp_msg.c stm32f10x_assert.c stm32f10x_it.c
    ../../User/bsp/src/: bsp_ad9833.c bsp_beep.c bsp_bh1750.c bsp_bmp180.c bsp_cpu_flash.c bsp_cpu_rtc.c bsp_dac8501.c bsp_dac8562.c bsp_dht11.c bsp_ds18b20.c bsp_eeprom_24xx.c bsp_esp8266.c bsp_fsmc_sram.c bsp_gt811.c bsp_hmc5883l.c bsp_i2c_gpio.c bsp_ir_decode.c bsp_key.c bsp_led.c bsp_modbus.c bsp_mpu6050.c bsp_nand_flash.c bsp_nor_flash.c bsp_oled.c bsp_ps2.c bsp_ra8875_flash.c bsp_ra8875_port.c bsp_rs485_led.c bsp_sdio_sd.c bsp_si4730.c bsp_sim800.c bsp_spi_bus.c bsp_spi_flash.c bsp_step_moto.c bsp_tft_lcd.c bsp_tim_pwm.c bsp_timer.c bsp_tm7705.c bsp_touch.c bsp_ts_ft5x06.c bsp_tsc2046.c bsp_uart_fifo.c bsp_user_lib.c bsp_vs1053b.c bsp_wm8978.c bsp_wwdg.c LCD_ILI9488.c LCD_RA8875.c LCD_SPFD5420.c
  group CH376
    ../../User/CH376/src/: FILE_SYS.C HAL_BASE.C SPI_SW.C
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt
  group EWARMv6
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_hd.s
  group FatFS
    ../../User/FatFS/src/option/: cc936.c
    ../../User/FatFS/src/: diskio.c ff.c
    ../../User/FatFS/: FatFS移植记录.txt
  group Fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group Images
    ../../User/images/: ADC.c Camera.c ChiLun.c chujiao.c FM.c GPS.c hwinfo.c images.h LCD.c MP3.c Phone.c radio.c Recorder.c USBDisk.c web.c Wireless.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uIP
    ../../User/uIP/uip/: psock.c timer.c uip-fw.c uip-neighbor.c uip-split.c uip.c uip_arp.c uiplib.c
  group uIP-DM9000
    ../../User/uIP/dm9000/: clock-arch.c dm9k_uip.c tapdev.c
  group uIP-HTTP
    ../../User/uIP/http/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
  group USB_FS_Device_Driver
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USBD MassStorage
    ../../User/usb_mass/: mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_hw.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
