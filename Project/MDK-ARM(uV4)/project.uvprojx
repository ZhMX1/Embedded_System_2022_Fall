# Keil uVision project project.uvprojx, settings and files
target Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\app\inc;..\..\User\fonts;..\..\User\images;..\..\User\uIP\uip;..\..\User\uIP\http;..\..\User\uIP\dm9000;..\..\User\FatFS\src;..\..\User\usb_mass;..\..\User\CH376\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../../User/app/src/: audio_rec.c bmp_file.c fm_radio.c gprs_test.c hard_test.c http_server.c main.c main_menu.c mems_test.c num_pad.c oled_test.c param.c ra8875_flash.c reserve.c touch_test.c usbd_msc_test.c mp3_player.c ad7705_test.c form_rs485.c form_dac8501.c form_dac8562.c form_dso.c WaveMaker.c wifi_test.c form_step_moto.c form_ad9833.c form_can.c can_network.c
  group BSP
    ../../User/bsp/src/: bsp_beep.c bsp_bh1750.c bsp_cpu_flash.c bsp_dac8501.c bsp_dac8562.c bsp_dht11.c bsp_ds18b20.c bsp_eeprom_24xx.c bsp_fsmc_sram.c bsp_gt811.c bsp_hmc5883l.c bsp_i2c_gpio.c bsp_key.c bsp_led.c bsp_modbus.c bsp_mpu6050.c bsp_nand_flash.c bsp_nor_flash.c bsp_oled.c bsp_ps2.c bsp_ra8875_flash.c bsp_ra8875_port.c bsp_rs485_led.c bsp_sdio_sd.c bsp_spi_bus.c bsp_spi_flash.c bsp_tft_lcd.c bsp_tim_pwm.c bsp_timer.c bsp_tm7705.c bsp_touch.c bsp_tsc2046.c bsp_uart_fifo.c bsp_user_lib.c bsp_vs1053b.c bsp_wm8978.c bsp_wwdg.c LCD_ILI9488.c LCD_RA8875.c LCD_SPFD5420.c bsp_sim800.c bsp_bmp180.c bsp_ir_decode.c bsp_si4730.c bsp_esp8266.c bsp_step_moto.c bsp_ad9833.c bsp_cpu_rtc.c bsp_ts_ft5x06.c
    ../../User/bsp/: bsp.h bsp_msg.h bsp.c stm32f10x_it.c stm32f10x_assert.c bsp_msg.c bsp_维护记录.txt
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt
  group Fonts
    ../../User/fonts/: asc12.c asc16.c hz12.c hz16.c fonts.h 说明.txt hz24.c hz32.c ra8875_asc_width.c
  group Images
    ../../User/images/: images.h Camera.c ChiLun.c chujiao.c Recorder.c hwinfo.c web.c LCD.c Wireless.c radio.c GPS.c Phone.c MP3.c USBDisk.c ADC.c
  group uIP
    ../../User/uIP/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group uIP-DM9000
    ../../User/uIP/dm9000/: tapdev.c dm9k_uip.c clock-arch.c
  group uIP-HTTP
    ../../User/uIP/http/: http-strings.c httpd.c httpd-cgi.c httpd-fs.c
  group USBD MassStorage
    ../../User/usb_mass/: mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_hw.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group FatFS
    ../../User/FatFS/src/: diskio.c ff.c
    ../../User/FatFS/src/option/: cc936.c
    ../../User/FatFS/: FatFS移植记录.txt
  group USB FS Device Driver
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group CH376
    ../../User/CH376/src/: FILE_SYS.C HAL_BASE.C SPI_SW.C
target CpuRAM (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.0.1
